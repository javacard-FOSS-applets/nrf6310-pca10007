# Keil uVision project ant_temp.uvproj, settings and files
target Master (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: nRF51422_xxAA Nordic Semiconductor
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ant_temp +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: DEBUG NRF51 BOARD_NRF6310 SOFTDEVICE_PRESENT ANT_STACK_SUPPORT_REQD ENABLE_DEBUG_LOG_SUPPORT S210 BOARD_PCA10007
  c include: .\;.\Include;.\Include\ant\softdevice;.\Include\app_common;.\Include\gcc;.\Include\TinyAES;.\Include\segger_rtt
  memory RVCT4: ROM 0xa000 size 0x36000
  memory RVCT5: ROM 0x0 size 0x1000
  memory RVCT9: RAM 0x20000900 size 0x3700
  group MBR
    ./: mbr.a
  group Functions
    ./: Universal.h Segger_functions.c GPIO_functions.c Pin_RST.c Pin_VCC.c CLK_Gen_functions.c UART_same_pin.c UART_functions.c Misc_functions.c EncodeDecode.c Bootloader.c Segmenter.c GlobalInit_functions.c
    ./Include/nrf_delay/: nrf_delay.c
    ./Include/segger_rtt/: SEGGER_RTT.c
  group ISO7816
    ./: ISO7816.h ISO7816_errors.h ISO7816_init.c ISO7816_error_functions.c ISO7816_activation_sequences.c ISO7816_ATR_functions.c ISO7816_Message_Checks.c ISO7816_Messages_functions.c ISO7816_Misc_functions.c ISO7816_APDU_tests.c ISO7816_send_recieve.c iso7816_functions.c ISO7816_Segger_UART_7816_converter.c ISO7816_timing_calc_functions.c ISO7816_Applet_Communication.c ISO7816_Applet_functions.c ISO7816_uart_iso_converter_Standalone.c
  group Crypto
    ./: PSK.h
    ./Include/TinyAES/: aes.h aes.c test.c
  group main
    ./Include/toolchain/arm/: arm_startup_nrf51.s
    ./Include/toolchain/: system_nrf51.c
    ./Include/templates/: system_nrf51422.c
    ./: main.c
  group Slave
    ./: Slave.c
  group Master
    ./: Master.c
  group GPIO_CLK
    ./Include/gpiote/: nrf_drv_gpiote.c
    ./: CLK_Gen.c
  group UART
    ./: UART_test.c
target Slave (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: nRF51422_xxAA Nordic Semiconductor
  cpu: as above
  output: ant_temp +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: as above
  c include: as above
  memory RVCT4: ROM 0xa000 size 0x36000
  memory RVCT5: ROM 0x0 size 0x1000
  memory RVCT9: RAM 0x20000900 size 0x3700
target nrf54122_xxaa_main (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: nRF51422_xxAA Nordic Semiconductor
  cpu: as above
  output: ant_temp +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: as above
  c include: as above
  memory RVCT4: ROM 0xa000 size 0x36000
  memory RVCT5: ROM 0x0 size 0x1000
  memory RVCT9: RAM 0x20000900 size 0x3700
target nrf54122_xxaa_MBR (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: nRF51422_xxAA Nordic Semiconductor
  cpu: as above
  output: ant_temp +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: NRF51 BOARD_NRF6310 SOFTDEVICE_PRESENT ANT_STACK_SUPPORT_REQD ENABLE_DEBUG_LOG_SUPPORT S210 BOARD_PCA10007
  c include: as above
  memory RVCT4: ROM 0x0 size 0x1000
  memory RVCT5: ROM 0xfffffff0 size 0x10
  memory RVCT9: RAM 0x20000900 size 0x3700
target GPIO_CLK (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: nRF51422_xxAA Nordic Semiconductor
  cpu: as above
  output: ant_temp +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: as above
  c include: .\;.\Include;.\Include\utils;.\Include\ant\softdevice;.\Include\app_common;.\Include\gcc;.\Include\TinyAES;.\Include\segger_rtt;.\Include\gpiote;.\Include\hal
  memory RVCT4: ROM 0xa000 size 0x36000
  memory RVCT5: ROM 0x0 size 0x1000
  memory RVCT9: RAM 0x20000900 size 0x3700
target UART_TEST (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: nRF51422_xxAA Nordic Semiconductor
  cpu: as above
  output: ant_temp +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: as above
  c include: as above
  memory RVCT4: ROM 0xa000 size 0x36000
  memory RVCT5: ROM 0x0 size 0x1000
  memory RVCT9: RAM 0x20000900 size 0x3700
target ISO7816_Converter (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: nRF51422_xxAA Nordic Semiconductor
  cpu: as above
  output: ant_temp +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: as above
  c include: as above
  memory RVCT4: ROM 0xa000 size 0x36000
  memory RVCT5: ROM 0x0 size 0x1000
  memory RVCT9: RAM 0x20000900 size 0x3700
